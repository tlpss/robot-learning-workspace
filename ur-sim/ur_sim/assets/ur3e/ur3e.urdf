Commit message: fix inertial properties of fixed links

File: ur-sim/ur_sim/assets/ur3e/ur3e.urdf (robot description, URDF)
Before this commit: robot ur3e, 12 links, 11 joints
Links:
- link flange: mass None -> 0.0
- link tool0: mass None -> 0.0
