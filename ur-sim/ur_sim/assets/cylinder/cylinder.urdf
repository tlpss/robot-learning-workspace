Commit message: increase weight for better stability

File: ur-sim/ur_sim/assets/cylinder/cylinder.urdf (robot description, URDF)
Before this commit: robot cylinder.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .3 -> 5
